SSID ?= "-|-SPAM-|-"
PSK ?= "HubSchrauberPilot"
