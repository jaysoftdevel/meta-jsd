SYSTEMD_SERVICE:${PN} = "systemd-networkd.service systemd-resolved.service"
