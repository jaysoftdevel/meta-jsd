COMPATIBLE_MACHINE += "|beaglebone"
