#LICENSE = "closed"
PACKAGECONFIG:append = " freetype"
DEPENDS:append = " freetype"