# Enable freetype support to allow use of drawtext filter
PACKAGECONFIG:append = " freetype"
